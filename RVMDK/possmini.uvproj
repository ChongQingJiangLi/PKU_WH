# Keil uVision project possmini.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: pku_wheelchair +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\src\IMU
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../src/STM32Lib/: core_cm3.c core_cm3.h misc.c misc.h stm32f10x.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_conf.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h system_stm32f10x.c system_stm32f10x.h
  group usr
    ../src/: GPIO.c hal.c hal.h main.c NVIC.c RCC.c stm32f10x_it.c TIM.c USART.C can.c delay.c
  group asm
    ../src/STM32Lib/StartUp/: startup_stm32f10x_hd.s
  group SCI
    ../src/SCI/: sci.c sci.h
  group IMU
    ../src/IMU/: MPU6050.c I2C.c imu.h
  group SIGNAL
    ../src/ISR/: isr.c isr.h
  group Proc
    ../src/Proc/: processor.c
  group motor
    ../src/: motor.c motor.h
  group BUZ
    ../src/: buz.c buz.h
